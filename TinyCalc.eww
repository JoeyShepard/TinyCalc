<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\emulated\emulated.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TinyCalc.ewp</path>
    </project>
    <batchBuild />
</workspace>
